options:
  parameters:
    author: huangziang
    generate_options: no_gui
    id: GFSK_RX
    output_language: python
    title: GFSK-RX
  states: {}

blocks:
- name: SPS
  id: variable
  parameters:
    value: '47'
  states: {}
- name: access_code
  id: variable
  parameters:
    value: globals().get('CONFIG', {}).get('access_code', '0001011011101000110100110111011100010101000111000111000100101101')
  states: {}
- name: demod_sensitivity
  id: variable
  parameters:
    value: globals().get('CONFIG', {}).get('sensitivity', 2.8194)
  states: {}
- name: lpf_cutoff
  id: variable
  parameters:
    value: globals().get('CONFIG', {}).get('bandwidth', 500000)
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.141592653589793'
  states: {}
- name: rx_frequency
  id: variable
  parameters:
    value: globals().get('CONFIG', {}).get('frequency', 432200000)
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sdr_uri
  id: variable
  parameters:
    value: globals().get('CONFIG', {}).get('sdr_uri', '192.168.1.10')
  states: {}
- name: tcp_port
  id: variable
  parameters:
    value: globals().get('CONFIG', {}).get('tcp_port', 2500)
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '15'
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_code
    tagname: access_code+header
    threshold: '12'
    type: byte
  states: {}
- name: digital_gfsk_demod_0_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: SPS
    sensitivity: 1/demod_sensitivity
  states: {}
- name: iio_pluto_source_1
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: rx_frequency
    gain1: '''manual'''
    manual_gain1: '60'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: sample_rate
    type: fc32
    uri: sdr_uri
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lpf_cutoff
    decim: '1'
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: network_tcp_sink_0_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: tcp_port
    type: byte
  states: {}

connections:
- [blocks_pack_k_bits_bb_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', network_tcp_sink_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_gfsk_demod_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [iio_pluto_source_1, '0', low_pass_filter_0_0, '0']
- [low_pass_filter_0_0, '0', digital_gfsk_demod_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
